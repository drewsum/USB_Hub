# Repository drewsum/USB_Hub

File README.md:

# USB_Hub
A DIY USB hub with digital monitoring on all ports

## KiCad design hdw/USB_Hub/USB_Hub.kicad_pcb

Board: 4 copper layers, 50.0 x 50.0 mm, 204 parts (90 on the bottom side), 112 nets.

Parts:
C201, C304: 10nF; C_0603
C202, C301, C305, C402, C501, C502, C503, C504, C601, C602, C603, C604, C605, C701, C702, C703, C704, C705, C706, C707, C708, C709, C710, C901, C902, C903, C904, C905, C907, C908, C909, C1403, C1501, C1502: 0.1uF; C_0603
C203, C1003, C1103, C1203, C1303: 100uF; CP_EIA-7343-43_Kemet-X
C302, C306, C307, C308: 10uF; C_1206
C303, C401, C403, C404, C906, C910: 10uF; C_0603
C1001, C1002, C1101, C1102, C1201, C1202, C1301, C1302, C1401, C1402: 22pF; C_0603
D201: 24V; D_SMA
D301: BAT48JFILM; D_SOD-323
D601, D602, D603, D604, D605, D701, D702, D703, D704, D710: Green; LED_0603
D705, D706, D707, D708, D709: Red; LED_0603
D1001, D1101, D1201, D1301: SP0503BAHT; SOT-143
H801, H802, H803, H804: 3mm Mounting Hole; MountingHole_3mm
J201: +12V IN; BARREL_JACK
J1001, J1101, J1201, J1301: USB_A; USB_A_Wuerth_614004134726_Horizontal
J1401: USB_B_Mini; USB_Mini-B
L301: 2.2uH; L_Vishay_IHLP-2020
L901: 600R 0.5A; L_0603
Q301: BSS214NW; SOT-323_SC-70
Q302: ZXMS6004FFTA; SOT-23
R201: 51.1k; R_0603
R202, R404: 1.15k; R_0603
R203, R207: 5.11k; R_0603
R204, R205, R208, R304, R305, R401, R402, R501, R509, R605, R903, R904, R905, R906, R907, R1501, R1502, R1503, R1504, R1505, R1506, R1507, R1508: 10k; R_0603
R206: 13k; R_0603
R301: 2.67k; R_0603
R302, R306, R901: 10; R_0603
R303: 1.37k; R_0603
R307: 953k; R_0603
R308: 180k; R_0603
R403: 3.57k; R_0603
R502, R504, R506, R508: 4.99k; R_0603
R503, R510: 18.7k; R_0603
R505, R507: 23.7k; R_0603
R601, R602, R603, R604, R606, R701, R702, R703, R704, R705, R706, R707, R708, R709, R710, R902: 1k; R_0603
R1001, R1002, R1101, R1102, R1201, R1202, R1301, R1302, R1401, R1402: 27; R_0603
SW901: RESET; SW_PUSH_6mm
TP201: TP; PinHeader_1x01_P2.54mm_Horizontal
TP202, TP203, TP301, TP401, TP501, TP1401: TP; Test_Point
U201: TPS26600RHFT; QFN-24-1EP_4x5mm_Pitch0.5mm
U301, U601, U602, U603, U604, U605, U701, U702, U703, U704, U705, U706, U707, U708, U709, U710, U901: 74LVC1G97; SOT-363_SC-70-6
U302: TPS62133; QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm
U401: TPS7A92; Texas_S-PDSO-N10_EP1.2x2mm
U501: TPS2121RUXR; 12-VQFN-HR_2x2p5
U902: TPS3808G33; SOT-23-6
U903: M93C46-WMN6TP; SOIC-8_3.9x4.9mm_P1.27mm
U904: 74LVC1G373; SOT-363_SC-70-6
U905: TUSB2046BIRHBT; VQFN-32-1EP_5x5mm_P0.5mm_EP3.5x3.5mm
U1401: TPD3S044DBVR; SOT-23-6
U1501, U1502: TPS2042BDGN; MSOP-8-1EP_3x3mm_Pitch0.65mm
X901: ASE-48.000MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3.3V: C403.1, C404.1, C604.1, C902.1, C903.1, C904.1, C907.1, C908.1, C909.1, C910.1, L901.2, R401.1, R403.1, R509.1, R604.1, R905.1, R1501.1, R1502.1, R1503.1, R1504.1, R1505.1, R1506.1, R1507.1, R1508.1, TP401.1 (TP), U401.1 (OUT), U401.2 (OUT), U604.1 (VCC), U604.5 (VCC), U901.5 (VCC), U902.5 (SENSE), U902.6 (VDD), U903.6 (ORG), U903.8 (VCC), U904.5 (VCC), U905.3 (VCC), U905.25 (VCC), U905.30 (XTAL1), U905.31 (TSTMODE)
+5V: C401.1, C503.1, C601.1, C602.1, C701.1, C702.1, C703.1, C704.1, C705.1, C706.1, C707.1, C708.1, C709.1, C710.1, C1501.1, C1502.1, R402.1, R601.1, R602.1, R701.1, R702.1, R703.1, R704.1, R705.1, R706.1, R707.1, R708.1, R709.1, R710.1, TP501.1 (TP), U401.6 (SS_CTRL), U401.9 (IN), U401.10 (IN), U501.1 (OUT), U501.8 (OUT), U601.1 (VCC), U601.5 (VCC), U602.1 (VCC), U602.5 (VCC), U701.5 (VCC), U702.5 (VCC), U703.5 (VCC), U704.5 (VCC), U705.5 (VCC), U706.5 (VCC), U707.5 (VCC), U708.5 (VCC), U709.1 (VCC), U709.5 (VCC), U710.1 (VCC), U710.5 (VCC), U1501.2 (IN1), U1502.2 (IN1)
+5VP: C301.1, C306.1, C307.1, C501.1, C603.1, D301.2 (A), L301.2, Q302.3 (D), R304.1, R307.1, R501.1, R505.1, R603.1, TP301.1 (TP), U301.5 (VCC), U302.14 (VOS), U501.7 (IN1), U603.1 (VCC), U603.5 (VCC)
+12V: C203.1, C302.1, C305.1, C308.1, R206.1, TP203.1 (TP), U201.23 (OUT), U201.24 (OUT), U302.10 (AVIN), U302.11 (PVIN), U302.12 (PVIN)
+12Vin: C202.1, D201.1 (A1), J201.1, R201.1, R204.1, TP202.1 (TP), U201.8 (IN), U201.9 (IN)
/Downstream Port 0/DFP0_USB_CONN_D+: D1001.4 (K), J1001.3 (D+), R1001.1
/Downstream Port 0/DFP0_USB_CONN_D-: D1001.3 (K), J1001.2 (D-), R1002.1
/Downstream Port 1/DFP1_USB_CONN_D+: D1101.4 (K), J1101.3 (D+), R1101.1
/Downstream Port 1/DFP1_USB_CONN_D-: D1101.3 (K), J1101.2 (D-), R1102.1
/Downstream Port 2/DFP2_USB_CONN_D+: D1201.4 (K), J1201.3 (D+), R1201.1
/Downstream Port 2/DFP2_USB_CONN_D-: D1201.3 (K), J1201.2 (D-), R1202.1
/Downstream Port 3/DFP3_USB_CONN_D+: D1301.4 (K), J1301.3 (D+), R1301.1
/Downstream Port 3/DFP3_USB_CONN_D-: D1301.3 (K), J1301.2 (D-), R1302.1
/Upstream Port/UFP_USB_CONN_USB+: J1401.3 (D+), R1401.1
/Upstream Port/UFP_USB_CONN_USB-: J1401.2 (D-), R1402.1
CHASSIS: J1001.5 (Shield), J1101.5 (Shield), J1201.5 (Shield), J1301.5 (Shield), J1401.6 (Shield)
DFP0_USB_D+: C1001.1, R1001.2, U905.12 (DP1)
DFP0_USB_D-: C1002.1, R1002.2, U905.11 (DM1)
DFP0_VBUS: C1003.1, D1001.2 (K), J1001.1 (VBUS), U1501.7 (OUT1)
DFP1_USB_D+: C1101.1, R1101.2, U905.16 (DP2)
DFP1_USB_D-: C1102.1, R1102.2, U905.15 (DM2)
DFP1_VBUS: C1103.1, D1101.2 (K), J1101.1 (VBUS), U1501.6 (OUT2)
DFP2_USB_D+: C1201.1, R1201.2, U905.20 (DP3)
DFP2_USB_D-: C1202.1, R1202.2, U905.19 (DM3)
DFP2_VBUS: C1203.1, D1201.2 (K), J1201.1 (VBUS), U1502.7 (OUT1)
DFP3_USB_D+: C1301.1, R1301.2, U905.24 (DP4)
DFP3_USB_D-: C1302.1, R1302.2, U905.23 (DM4)
DFP3_VBUS: C1303.1, D1301.2 (K), J1301.1 (VBUS), U1502.6 (OUT2)
GND: C202.2, C203.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C401.2, C402.2, C403.2, C404.2, C501.2, C502.2, C503.2, C504.2, C601.2, C602.2, C603.2, C604.2, C605.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C901.2, C902.2, C903.2, C904.2, C905.2, C906.2, C907.2, C908.2, C909.2, C910.2, C1001.2, C1002.2, C1003.2, C1101.2, C1102.2, C1103.2, C1201.2, C1202.2, C1203.2, C1301.2, C1302.2, C1303.2, C1401.2, C1402.2, C1403.2, C1501.2, C1502.2, D201.2 (A2), D1001.1 (A), D1101.1 (A), D1201.1 (A), D1301.1 (A), J201.2, J201.3, J1001.4 (GND), J1101.4 (GND), J1201.4 (GND), J1301.4 (GND), J1401.5 (GND), Q301.2 (S), Q302.2 (S), R207.2, R301.2, R306.2, R308.2, R404.2, R502.2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
HUB_48MHCLK: R901.2, R903.1, U905.27 (TSTPLL/48MCLK)
HUB_BUSPWR: R907.1, U710.6, U904.4 (Q), U905.8 (BUSPWR)
HUB_CLK_EN: R904.1, U901.4, U904.1 (LE), X901.1 (EN)
HUB_EECLK: U903.2 (C), U905.5 (EECLK)
HUB_EEDATA: R902.1, U903.3 (D), U905.6 (EEDATA/GANGED)
HUB_SUSPND: R906.1, U709.6, U905.32 (SUSPND)
unnamed: C905.1, C906.1, L901.1, X901.4 (Vdd)
unnamed: C303.1, D301.1 (K), R305.1
unnamed: D601.2 (A), R601.2
unnamed: D601.1 (K), U601.4
unnamed: D602.2 (A), R602.2
unnamed: D602.1 (K), U602.4
unnamed: D603.2 (A), R603.2
unnamed: D603.1 (K), U603.4
unnamed: D604.2 (A), R604.2
unnamed: D604.1 (K), U604.4
unnamed: D605.2 (A), R606.2
unnamed: D605.1 (K), U605.4
unnamed: D701.2 (A), R701.2
unnamed: D701.1 (K), U701.4
unnamed: D702.2 (A), R702.2
unnamed: D702.1 (K), U702.4
unnamed: D703.2 (A), R703.2
unnamed: D703.1 (K), U703.4
unnamed: D704.2 (A), R704.2
unnamed: D704.1 (K), U704.4
unnamed: D705.2 (A), R705.2
unnamed: D705.1 (K), U705.4
unnamed: D706.2 (A), R706.2
unnamed: D706.1 (K), U706.4
unnamed: D707.2 (A), R707.2
unnamed: D707.1 (K), U707.4
unnamed: D708.2 (A), R708.2
unnamed: D708.1 (K), U708.4
unnamed: D709.2 (A), R709.2
unnamed: D709.1 (K), U709.4
unnamed: D710.2 (A), R710.2
unnamed: D710.1 (K), U710.4
unnamed: J1401.1 (VBUS), U1401.1 (EN), U1401.3 (IN)
unnamed: L301.1, U302.1 (SW), U302.2 (SW), U302.3 (SW)
unnamed: Q301.3 (D), Q302.1 (G), R305.2
unnamed: R303.2, U301.4
unnamed: R605.2, U605.6
unnamed: R205.1, U201.19 (ILIM)
unnamed: R208.1, U201.18 (IMON)
unnamed: R202.2, R203.1, U201.12 (OVP)
unnamed: C201.2, R203.2, R205.2, R208.2, U201.15 (RTN), U201.25 (RTN_PAD)
unnamed: R201.2, R202.1, U201.10 (UVLO)
unnamed: C201.1, U201.20 (dVdT)
unnamed: R204.2, U201.14 (~SHDN)
unnamed: R306.1, R307.2, R308.1, U302.5 (FB)
unnamed: R304.2, U301.6, U302.4 (PG)
unnamed: C304.1, U302.9 (SS/TR)
unnamed: R402.2, U401.7 (EN)
unnamed: R403.2, R404.1, U401.3 (FB)
unnamed: C402.1, U401.8 (NR/SS)
unnamed: R503.2, R504.1, U501.3 (CP2)
unnamed: R510.1, U501.10 (ILM)
unnamed: R505.2, R506.1, U501.5 (OV1)
unnamed: R507.2, R508.1, U501.4 (OV2)
unnamed: R501.2, R502.1, U501.6 (PR1)
unnamed: C504.1, U501.11 (SS)
unnamed: C901.1, U902.4 (CT)
unnamed: SW901.2, U902.3 (~MR)
unnamed: R902.2, U903.4 (Q)
unnamed: R901.1, X901.3 (OUT)
POS3P3_PGOOD: R401.2, U401.5 (PG), U604.6, U901.1
POS5P_PGOOD: R301.1, R303.1, U603.6
POS5P_RUN: Q301.1 (G), R302.2, U301.3, U302.13 (EN)
POS5_SOURCE_STATUS: R509.2, U501.9 (ST), U602.6, U904.3 (D)
POS12_PGOOD: R206.2, R207.1, R302.1, U201.22 (~FLT), U601.6
UFP_USB_D+: C1401.1, R1401.2, U905.1 (DP0), U1401.6 (D1)
UFP_USB_D-: C1402.1, R1402.2, U905.2 (DM0), U1401.5 (D2)
VBUS: C502.1, C605.1, C1403.1, R503.1, R507.1, R605.1, R606.1, TP1401.1 (TP), U501.2 (IN2), U605.1 (VCC), U605.5 (VCC), U1401.4 (OUT)
~DFP0_EN: R1505.2, U701.1, U905.9 (~PWRON1), U1501.3 (~EN1)
~DFP0_OC: R1501.2, U705.1, U905.10 (~OVRCUR1), U1501.8 (~OC1)
~DFP1_EN: R1507.2, U702.1, U905.13 (~PWRON2), U1501.4 (~EN2)
~DFP1_OC: R1503.2, U706.1, U905.14 (~OVRCUR2), U1501.5 (~OC2)
~DFP2_EN: R1506.2, U703.1, U905.17 (~PWRON3), U1502.3 (~EN1)
~DFP2_OC: R1502.2, U707.1, U905.18 (~OVRCUR3), U1502.8 (~OC1)
~DFP3_EN: R1508.2, U704.1, U905.21 (~PWRON4), U1502.4 (~EN2)
~DFP3_OC: R1504.2, U708.1, U905.22 (~OVRCUR4), U1502.5 (~OC2)
~HUB_RESET: R905.2, U902.1 (~RESET), U903.1 (S), U905.4 (~RESET)

File hdw/USB_Hub/USB_Hub_bom.csv:

Component,References,Value,Footprint,Quantity Per PCB,Digi-Key PN
1,C1001 C1002 C1101 C1102 C1201 C1202 C1301 C1302 C1401 C1402,22pF,C_0603,10,1292-1501-1-ND
2,C201 C304,10nF,C_0603,2,399-7842-1-ND
3,C202 C301 C305 C402 C501 C502 C503 C504 C601 C602 C603 C604 C605 C701 C702 C703 C704 C705 C706 C707 C708 C709 C710 C901 C902 C903 C904 C905 C907 C908 C909 C1403 C1501 C1502,0.1uF,C_0603,34,1276-1935-1-ND
4,C302 C306 C307 C308,10uF,C_1206,4,399-8153-1-ND
5,C303 C401 C403 C404 C906 C910,10uF,C_0603,6,399-8153-1-ND
6,C203 C1003 C1103 C1203 C1303,100uF,CP_EIA-7343-43_Kemet-X,5,718-1102-1-ND
8,D301,BAT48JFILM,D_SOD-323,1,497-5711-1-ND
9,D601 D602 D603 D604 D605 D701 D702 D703 D704 D710,Green,LED_0603,10,754-1121-1-ND
10,D705 D706 D707 D708 D709,Red,LED_0603,5,754-1117-1-ND
11,D1001 D1101 D1201 D1301,SP0503BAHT,SOT-143,4,F2715CT-ND
13,J1001 J1101 J1201 J1301,USB_A,USB_A_Wuerth_614004134726_Horizontal,4,732-2731-ND
14,J1401,USB_B_Mini,USB_Mini-B,1,732-2109-1-ND
15,L301,2.2uH,L_Vishay_IHLP-2020,1,541-1236-1-ND
16,L901,600R 0.5A,L_0603,1,MH1608-601YCT-ND
17,MK801 MK802 MK807 MK808,#4-40 Screw,,4,36-9900-ND
18,MK803 MK804 MK805 MK806,#4-40 Standoff,,4,36-1892-ND
19,N201,+12V 1A Power Supply,,1,993-1335-ND
20,Q301,BSS214NW,SOT-323_SC-70,1,BSS214NWH6327XTSA1CT-ND
21,Q302,ZXMS6004FFTA,SOT-23,1,ZXMS6004FFCT-ND
22,R302 R306 R901,10,R_0603,3,541-2982-1-ND
23,R1001 R1002 R1101 R1102 R1201 R1202 R1301 R1302 R1401 R1402,27,R_0603,10,541-27.0HCT-ND
24,R601 R602 R603 R604 R606 R701 R702 R703 R704 R705 R706 R707 R708 R709 R710 R902,1k,R_0603,16,541-1.00KHCT-ND
25,R202 R404,1.15k,R_0603,2,541-1.15KHCT-ND
26,R303,1.37k,R_0603,1,541-1.37KHCT-ND
27,R301,2.67k,R_0603,1,541-2.67KHCT-ND
28,R403,3.57k,R_0603,1,541-3.57KHCT-ND
29,R502 R504 R506 R508,4.99k,R_0603,4,541-4.99KHCT-ND
30,R203 R207,5.11k,R_0603,2,541-5.11KHCT-ND
31,R204 R205 R208 R304 R305 R401 R402 R501 R509 R605 R903 R904 R905 R906 R907 R1501 R1502 R1503 R1504 R1505 R1506 R1507 R1508,10k,R_0603,23,541-10.0KHCT-ND
32,R206,13k,R_0603,1,541-13.0KHCT-ND
33,R503 R510,18.7k,R_0603,2,541-18.7KHCT-ND
34,R505 R507,23.7k,R_0603,2,541-23.7KHCT-ND
35,R201,51.1k,R_0603,1,541-3009-1-ND
39,U904,74LVC1G373,SOT-363_SC-70-6,1,296-18775-1-ND
40,U301 U601 U602 U603 U604 U605 U709 U710 U901 U701 U702 U703 U704 U705 U706 U707 U708,74LVC1G97,SOT-363_SC-70-6,17,1727-1772-1-ND
44,U903,M93C46-WMN6TP,SOIC-8_3.9x4.9mm_P1.27mm,1,497-5090-1-ND
45,U1401,TPD3S044DBVR,SOT-23-6,1,296-38836-1-ND
46,U1501 U1502,TPS2042BDGN,MSOP-8-1EP_3x3mm_Pitch0.65mm,2,296-28003-1-ND
47,U501,TPS2121RUXR,12-VQFN-HR_2x2p5,1,296-53410-1-ND
48,U201,TPS26600RHFT,QFN-24-1EP_4x5mm_Pitch0.5mm,1,296-45478-1-ND
49,U902,TPS3808G33,SOT-23-6,1,296-17195-1-ND
50,U302,TPS62133,QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm,1,296-30225-1-ND
51,U401,TPS7A92,Texas_S-PDSO-N10_EP1.2x2mm,1,TPS7A9201DSKR
52,U905,TUSB2046BIRHBT,VQFN-32-1EP_5x5mm_P0.5mm_EP3.5x3.5mm,1,296-27130-1-ND
53,X901,ASE-48.000MHz,Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm,1,535-ASE-48.000MHZ-L-C-TCT-ND

## Commit log

2020-08-22 Started hdw project
2023-08-06 wokrked on this some more
2023-08-10 added new 4 port USB hub controller
2023-08-11 schematic progress
2023-08-18 lots of schematic progress
2023-08-18 much more schematic progress
2023-08-20 lots and lots of sch progress
2023-08-20 pulled footprints into layout
2023-08-21 random stuff
2023-09-06 big restructuring, removed microcontroller and all telemtry
2023-09-06 fixed footprints, assigned digikey pns
2023-09-15 pulled in fotprints into layout
2023-09-15 pulled in design rules
2023-09-15 some component placement
2023-09-15 VBUS power switch placement
2023-09-16 fixed some netlist connectivity issues, finished grouping parts in PCB
2023-09-17 created board outline
2023-09-17 finished placing parts in baoard outline
2023-09-17 added GND plane
2023-09-17 lots of PCB progress, fixed some netlist issues
2023-10-02 routed diff pairs
2023-10-02 random routing, via placement
2023-10-06 random power and signal routing
2023-10-06 lots of misc routing
2023-10-06 much more routing
2023-10-08 got unconnects to 0
2023-10-08 added some random PCB silkscreen/misc things
2023-10-14 generated BOM
