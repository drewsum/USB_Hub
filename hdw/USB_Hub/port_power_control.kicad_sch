File: hdw/USB_Hub/port_power_control.kicad_sch (KiCad schematic)
At the start: 23 parts, among them U2301 TPS2044D

Commit message: big restructuring, removed microcontroller and all telemtry
Parts:
- removed R? (x8): 10, Resistors_SMD:R_0402, symbol Custom_Library:R_Custom
- removed R? (x4): 0.02, Resistors_SMD:R_0612, symbol Custom_Library:R_Custom
- removed U2301: TPS2044D, Package_SO:SOIC-16_3.9x9.9mm_P1.27mm, symbol Power_Management:TPS2044D
- added U1501, U1502: TPS2042BDGN, Housings_SSOP:MSOP-8-1EP_3x3mm_Pitch0.65mm, symbol Power_Management:TPS2042D
Connections:
- net +5V: now also U1501.2 (IN1), U1502.2 (IN1)
- net DFP0_VBUS: now also U1501.7 (OUT1)
- net DFP1_VBUS: now also U1501.6 (OUT2)
- net DFP2_VBUS: now also U1502.7 (OUT1)
- net DFP3_VBUS: now also U1502.6 (OUT2)
- net GND: now also U1501.1 (GND), U1502.1 (GND)
- net ~{DFP0_EN}: now also U1501.3 (~{EN1})
- net ~{DFP0_OC}: now also U1501.8 (~{OC1})
- net ~{DFP1_EN}: now also U1501.4 (~{EN2})
- net ~{DFP1_OC}: now also U1501.5 (~{OC2})
- net ~{DFP2_EN}: now also U1502.3 (~{EN1})
- net ~{DFP2_OC}: now also U1502.8 (~{OC1})
- net ~{DFP3_EN}: now also U1502.4 (~{EN2})
- net ~{DFP3_OC}: now also U1502.5 (~{OC2})

Commit message: fixed footprints, assigned digikey pns
Parts:
- R? (x8): Digi-Key PN (none) -> 541-10.0KHCT-ND
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 86.36 105.41 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 86.36 105.41 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 93.98 105.41 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 93.98 105.41 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 78.74 105.41 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 78.74 105.41 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 93.98 41.91 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 93.98 41.91 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 78.74 41.91 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 78.74 41.91 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 71.12 105.41 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 71.12 105.41 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 71.12 41.91 0)
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 71.12 41.91 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Digi-Key PN" "" (at 86.36 41.91 0)
-      (effects (font (size 1.524 1.524)) hide)
-    )
+    (property "Digi-Key PN" "541-10.0KHCT-ND" (at 86.36 41.91 0)
+      (effects (font (size 1.524 1.524)) hide)
+    )
