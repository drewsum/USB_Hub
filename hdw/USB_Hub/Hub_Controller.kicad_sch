File: hdw/USB_Hub/Hub_Controller.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: added new 4 port USB hub controller
Parts:
- removed U?: TUSB2036, Package_QFP:LQFP-32_7x7mm_P0.8mm, symbol Interface_USB:TUSB2036
- added R?: 1k, Resistors_SMD:R_0603, symbol Custom_Library:R_Custom
- added U?: M93C46-WMN6TP, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Custom Library:M93C46-WMN6TP
- added U?: TUSB2046BIRHBT, Package_DFN_QFN:VQFN-32-1EP_5x5mm_P0.5mm_EP3.5x3.5mm, symbol Custom Library:TUSB2046BIRHBT
Connections:
- new net: R?.2, U?.4 (Q)
- new net +3.3V: U?.25 (VCC), U?.3 (VCC), U?.30 (XTAL1), U?.31 (TSTMODE), U?.6 (ORG), U?.8 (VCC)
- new net DFP0_USB_D+: U?.12 (DP1)
- new net DFP0_USB_D-: U?.11 (DM1)
- new net DFP1_USB_D+: U?.16 (DP2)
- new net DFP1_USB_D-: U?.15 (DM2)
- new net DFP2_USB_D+: U?.20 (DP3)
- new net DFP2_USB_D-: U?.19 (DM3)
- new net DFP3_USB_D+: U?.24 (DP4)
- new net DFP3_USB_D-: U?.23 (DM4)
- new net GND: U?.26 (~{EXTMEM}), U?.28 (GND), U?.33 (EP), U?.5 (VSS), U?.7 (GND)
- new net HUB_48MHCLK: U?.27 (TSTPLL/48MCLK)
- new net HUB_EECLK: U?.2 (C), U?.5 (EECLK)
- new net HUB_EEDATA: R?.1, U?.3 (D), U?.6 (EEDATA/GANGED)
- new net UFP_USB_D+: U?.1 (DP0)
- new net UFP_USB_D-: U?.2 (DM0)
- new net ~{DFP0_EN}: U?.9 (~{PWRON1})
- new net ~{DFP0_OC}: U?.10 (~{OVRCUR1})
- new net ~{DFP1_EN}: U?.13 (~{PWRON2})
- new net ~{DFP1_OC}: U?.14 (~{OVRCUR2})
- new net ~{DFP2_EN}: U?.17 (~{PWRON3})
- new net ~{DFP2_OC}: U?.18 (~{OVRCUR3})
- new net ~{DFP3_EN}: U?.21 (~{PWRON4})
- new net ~{DFP3_OC}: U?.22 (~{OVRCUR4})
- new net ~{HUB_RESET}: U?.1 (S), U?.4 (~{RESET})
- no-connect marks 0 -> 1
Other:
- note added: "Strap PLL for 48MHz clocking option See Figure 7 of D/S"
- note removed: "Copy symbol to TUSB2046B"

Commit message: schematic progress
Parts:
- added C1002, C?: 0.1uF, Capacitors_SMD:C_0402, symbol Custom_Library:C_Custom
- added C?: 10uF, Capacitors_SMD:C_0603, symbol Custom_Library:C_Custom
- added C? (x3): 0.1uF, Capacitors_SMD:C_0603, symbol Custom_Library:C_Custom
- added C?: 10uF, Capacitors_SMD:C_0402, symbol Custom_Library:C_Custom
- added L?: 600R 0.5A, Inductors_SMD:L_0402, symbol Device:Ferrite_Bead
- added R1003: 10, Resistors_SMD:R_0402, symbol Custom_Library:R_Custom
- added R? (x2): 10k, Resistors_SMD:R_0402, symbol Custom_Library:R_Custom
- added U1001: 74LVC1G97, Package_TO_SOT_SMD:SOT-363_SC-70-6, symbol Custom_Library:74LVC1G97_Power_BUF
- added U?: TPS3808DBV, Package_TO_SOT_SMD:SOT-23-6, symbol Power_Supervisor:TPS3808DBV
- added X1001: ASE-48.000MHz, Oscillator:Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm, symbol Oscillator:ASE-xxxMHz
Connections:
- net +3.3V: now also C?.1, C?.1, C?.1, C?.1, C?.1, L?.2, U1001.5 (VCC)
- net GND: now also C1002.2, C?.2, C?.2, C?.2, C?.2, C?.2, C?.2, R?.2, R?.2, U1001.2 (GND), U1001.3 (GND), U1001.6 (GND)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
- net HUB_48MHCLK: now also R1003.2, R?.1
- new net: R1003.1, X1001.3 (OUT)
- new net: C1002.1, C?.1, L?.1, X1001.4 (Vdd)
- new net HUB_CLK_EN: R?.1, U1001.4, X1001.1 (EN)
- new net POS3P3_PGOOD: U1001.1
Other:
- note added: "Figure out when to start clocking"
- note added: "Generally, a reset with a pulse width between 100 μs and 1 ms is recommended after 3.3-V VCC reaches its 90%. Clock signal has to be active during the last 60 μs of the reset window."
- moved on the sheet: U?

Commit message: lots of schematic progress
Parts:
- C1002, C?: footprint Capacitors_SMD:C_0402 -> Capacitors_SMD:C_0603; Digi-Key PN 490-10698-1-ND -> 1276-1935-1-ND; display_footprint 0402 -> 0603
- C?: footprint Capacitors_SMD:C_0402 -> Capacitors_SMD:C_0603; Digi-Key PN 1276-1451-1-ND -> 1276-1871-1-ND; Voltage 6.3V -> 10V; display_footprint 0402 -> 0603
Other:
- company: (none) -> Drew Maatman
- title: (none) -> USB Hub
- moved on the sheet: C?, R?, U?

Commit message: much more schematic progress
Parts:
- added C? (x2): 0.1uF, Capacitors_SMD:C_0603, symbol Custom_Library:C_Custom
- added R?: 10k, Resistors_SMD:R_0402, symbol Custom_Library:R_Custom
- U?: value TPS3808DBV -> TPS3808G33
Connections:
- net +3.3V: now also U?.5 (SENSE), U?.6 (VDD), C?.1, R?.1
- net GND: now also U?.2 (GND), C?.2, C?.2
- net ~{HUB_RESET}: now also U?.1 (~{RESET}), R?.2
- net ~{PIC18F_MCLR}: now reaches U?.3 (~{MR})
- net at U?.4 (CT): now also C?.1
Other:
- note removed: "Figure out when to start clocking"
- moved on the sheet: C?, R?, U?

Commit message: lots and lots of sch progress
Parts:
- added C?: 0.1uF, Capacitors_SMD:C_0603, symbol Custom_Library:C_Custom
- added R? (x2): 10k, Resistors_SMD:R_0402, symbol Custom_Library:R_Custom
- added U1704: 74LVC1G97, Package_TO_SOT_SMD:SOT-363_SC-70-6, symbol Custom Library:74LVC1G97_Power_NOT
- gave numbers to parts that had none: 3
- renumbered C1002 to C?, R1003 to R?, U1001 to U?, X1001 to X?
Connections:
- net +3.3V: now also C?.1, U1704.1 (VCC), U1704.5 (VCC)
- net GND: now also C?.2, R?.2, R?.2, U1704.2 (GND), U1704.3 (GND)
- net HUB_SUSPND: now reaches U1705.32 (SUSPND)
- net HUB_SUSPND: now also R?.1
- net HUB_BUSPWR: now reaches U1705.8 (BUSPWR)
- net HUB_BUSPWR: now also R?.1, U1704.4
- new net POS5_SOURCE_STATUS: U1704.6
Other:
- note added: "INVETIGATE CHANGING INVERTER TO INVERTED LATCH"
- moved on the sheet: C?, U1705
