File: hdw/USB_Hub/Hub_Controller.kicad_sch (KiCad schematic)
At the start: 24 parts, among them U1702 TPS3808G33, U1703 M93C46-WMN6TP, U1704 74LVC1G97, U1705 TUSB2046BIRHBT

Commit message: pulled footprints into layout
Parts:
- C? (x5): Digi-Key PN 399-7845-1-ND -> 1276-1935-1-ND
- R? (x5): Digi-Key PN RMCF0402FT10K0CT-ND -> (none); Wattage 1/16W -> 1/10W; display_footprint 0402 -> 0603
- R?: Digi-Key PN 311-1.00KHRCT-ND -> (none)
- R?: Digi-Key PN RMCF0402FT10R0CT-ND -> (none); Wattage 1/16W -> 1/10W; display_footprint 0402 -> 0603
- U1704: Digi-Key PN (none) -> 296-15582-1-ND
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "display_footprint" "0402" (at 89.662 110.998 0)
+    (property "display_footprint" "0603" (at 89.662 110.998 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Wattage" "1/16W" (at 89.662 114.808 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Digi-Key PN" "RMCF0402FT10K0CT-ND" (at 91.44 113.03 0)
+    (property "Wattage" "1/10W" (at 89.662 114.808 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Digi-Key PN" "" (at 91.44 113.03 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Digi-Key PN" "311-1.00KHRCT-ND" (at 85.09 167.005 0)
+    (property "Digi-Key PN" "" (at 85.09 167.005 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Datasheet" "http://www.ti.com/lit/ds/symlink/sn74lvc1g97.pdf" (at 167.64 146.05 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Digi-Key PN" "296-15582-1-ND" (at 166.37 146.05 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Digi-Key PN" "399-7845-1-ND" (at 197.485 10.16 0)
+    (property "Digi-Key PN" "1276-1935-1-ND" (at 197.485 10.16 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "display_footprint" "0402" (at 80.01 55.88 90)
+    (property "display_footprint" "0603" (at 80.01 55.88 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Wattage" "1/16W" (at 80.01 50.8 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Digi-Key PN" "RMCF0402FT10R0CT-ND" (at 69.85 50.8 0)
+    (property "Wattage" "1/10W" (at 80.01 50.8 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Digi-Key PN" "" (at 69.85 50.8 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Digi-Key PN" "399-7845-1-ND" (at 57.785 113.03 0)
+    (property "Digi-Key PN" "1276-1935-1-ND" (at 57.785 113.03 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Digi-Key PN" "399-7845-1-ND" (at 42.545 100.33 0)
+    (property "Digi-Key PN" "1276-1935-1-ND" (at 42.545 100.33 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Digi-Key PN" "399-7845-1-ND" (at 75.565 136.525 0)
+    (property "Digi-Key PN" "1276-1935-1-ND" (at 75.565 136.525 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "display_footprint" "0402" (at 189.992 149.098 0)
+    (property "display_footprint" "0603" (at 189.992 149.098 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Wattage" "1/16W" (at 189.992 152.908 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Digi-Key PN" "RMCF0402FT10K0CT-ND" (at 191.77 151.13 0)
+    (property "Wattage" "1/10W" (at 189.992 152.908 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Digi-Key PN" "" (at 191.77 151.13 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "display_footprint" "0402" (at 163.322 105.918 0)
+    (property "display_footprint" "0603" (at 163.322 105.918 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Wattage" "1/16W" (at 163.322 109.728 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Digi-Key PN" "RMCF0402FT10K0CT-ND" (at 165.1 107.95 0)
+    (property "Wattage" "1/10W" (at 163.322 109.728 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Digi-Key PN" "" (at 165.1 107.95 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "display_footprint" "0402" (at 89.662 61.468 0)
+    (property "display_footprint" "0603" (at 89.662 61.468 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Wattage" "1/16W" (at 89.662 65.278 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Digi-Key PN" "RMCF0402FT10K0CT-ND" (at 91.44 63.5 0)
+    (property "Wattage" "1/10W" (at 89.662 65.278 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Digi-Key PN" "" (at 91.44 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Digi-Key PN" "399-7845-1-ND" (at 222.885 10.16 0)
+    (property "Digi-Key PN" "1276-1935-1-ND" (at 222.885 10.16 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "display_footprint" "0402" (at 89.662 89.408 0)
+    (property "display_footprint" "0603" (at 89.662 89.408 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Wattage" "1/16W" (at 89.662 93.218 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Digi-Key PN" "RMCF0402FT10K0CT-ND" (at 91.44 91.44 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Wattage" "1/10W" (at 89.662 93.218 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Digi-Key PN" "" (at 91.44 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: big restructuring, removed microcontroller and all telemtry
Parts:
- removed U1704: 74LVC1G97, Package_TO_SOT_SMD:SOT-363_SC-70-6, symbol Custom Library:74LVC1G97_Power_NOT
- added SW901: RESET, symbol Switch:SW_Push
- added U904: 74LVC1G373, symbol 74xGxx:74LVC1G373
- gave numbers to parts that had none: 1
- renumbered U1702 to U902, U1703 to U903, U1705 to U905
Connections:
- net +3.3V: now also U904.5 (VCC)
- net GND: now also SW901.1, U904.2 (GND), U904.6 (~{OE})
- net HUB_BUSPWR: now also U904.4 (Q)
- net HUB_CLK_EN: now also U904.1 (LE)
- net POS5_SOURCE_STATUS: now also U904.3 (D)
- net ~{PIC18F_MCLR}: no longer names the net of U902.3 (~{MR})
- net ~{PIC18F_MCLR}: now also SW901.2
Other:
- note added: "High when wall wart powering output, low when upstream VBUS powering output. This should not change during operation"
- note removed: "INVETIGATE CHANGING INVERTER TO INVERTED LATCH"
- moved on the sheet: C?, R?
